# Keil uVision project DEMO.uvproj, settings and files
target simulator (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Startup;..\Libraries\inc;..\Libraries\src;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_flash.c stm32f10x_tim.c
    ../Driver/: stm32f10x_systick.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Driver
    ../Driver/: Driver.c System_Init.c mpu6050_driver.c I2C_driver.c ImitateI2C.c TIM_driver.c NRF24L01_Driver.c NRF24L01_Driver_send.c Control_Driver.c
  group Head
    ../Driver/: Driver.h System_Init.h mpu6050_driver.h Type.h NRF24L01_Driver.h NRF24L01_Driver_send.h Control_Driver.h
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
target SRAM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x6000
target flash (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
