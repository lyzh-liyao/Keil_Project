# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Startup;..\Libraries\inc;..\Libraries\src;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
    ../Driver/: stm32f10x_systick.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Driver
    ../Driver/: Driver.c
