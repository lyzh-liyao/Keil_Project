# Keil uVision project DEMO.uvproj, settings and files
target simulator (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Startup;..\Libraries\inc;..\Libraries\src;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Driver\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Driver
    ../Driver/: Driver.c STM32_DevInit.c tool.c protocol.c RudderControl.c UltrasonicControl.c MotorControl.c PID.c UartCMD.c MPU6050.c Filter.c Strategy.c
  group Include
    ../Driver/: Driver.h STM32_DevInit.h stm32f10x_systick.h tool.h protocol.h RudderControl.h UltrasonicControl.h MotorControl.h PID.h UartCMD.h MPU6050.h Filter.h Strategy.h
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group LibInclude
    ../Libraries/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h stm32f10x_systick.h
  group OLED
    ../Driver/OLED/: bmp.h oled.c oled.h oledfont.h
target SRAM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Startup;..\Libraries\inc;..\Libraries\src;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x6000
target flash (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
