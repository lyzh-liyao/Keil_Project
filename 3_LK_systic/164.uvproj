# Keil uVision project 164.uvproj, settings and files
target simulator (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 164
  c flags: Optim=1
  c include: .\lib\inc;.\User;.\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group LibC
    ./lib/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_systick.c stm32f10x_spi.c
  group Start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
  group Driver
    ./Driver/: Driver.c
target Flash (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: 164 +hex
  c flags: Optim=1
  c include: .\lib\inc;.\User;.\Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target Ram (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: 164 +hex
  c flags: Optim=1
  c define: VECT_TAB_RAM
  c include: .\lib\inc;.\User;.\Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
